
IMAGE_FSTYPES:append = " ext4 "
IMAGE_INSTALL:append = " rauc u-boot u-boot-fw-utils "